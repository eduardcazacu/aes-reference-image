SRC_URI += "file://user_2020-09-29-15-24-00.cfg \
            file://user_2020-12-01-19-58-00.cfg \
            file://user_2020-12-07-16-33-00.cfg \
            file://user_2021-02-12-16-05-00.cfg \
            file://user_2021-02-14-11-33-00.cfg \
            file://user_2021-06-24-15-19-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

